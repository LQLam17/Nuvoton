# Keil uVision project bsp_nuc220xx.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: NUC220LE3AN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: bsp_nuc220xx +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6LangP=2 wLevel=1
  c include: ..\cpu_src\Library\CMSIS\Include;..\cpu_src\Library\Device\Nuvoton\NUC200Series\Include;..\cpu_src\Library\StdDriver\inc;..\bsp_src;..\indep_src
  library: MicroLIB
  memory RVCT4: ROM 0xc000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group bsp_src
    ../bsp_src/: bsp_nuc220x_UART.c bsp_nuc220x_system.c bsp_nuc220x_RTC.c bsp_nuc220x_BootLoader.c
  group cpu_src
    ../cpu_src/Library/Device/Nuvoton/NUC200Series/Source/: system_NUC200Series.c
    ../cpu_src/Library/Device/Nuvoton/NUC200Series/Source/ARM/: startup_NUC200Series.s
    ../cpu_src/Library/StdDriver/src/: acmp.c clk.c fmc.c gpio.c retarget.c rtc.c sys.c timer.c uart.c wdt.c
  group indep_src
    ../indep_src/: main.c
